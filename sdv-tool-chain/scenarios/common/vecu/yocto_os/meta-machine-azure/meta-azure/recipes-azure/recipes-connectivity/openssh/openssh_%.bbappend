# -------------------------------------------------------------------------------------------
# Configure openssh for using on Azure
#
# reference: https://learn.microsoft.com/en-us/azure/virtual-machines/linux/provisioning
# source: collaboration with ARM to build a reference image for azure based on EWAOL
# -------------------------------------------------------------------------------------------
FILESEXTRAPATHS:prepend = "${THISDIR}/files:"
